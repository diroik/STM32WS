<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\IAR_Powercharger\IAP_01.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MKAB_LAST_WORK_WDT\MKAB-12.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\PLC-1\plc1.ewp</path>
    </project>
    <batchBuild />
</workspace>
