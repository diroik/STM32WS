# IAR project plc1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100C8 ST STM32F100C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD_VL; UM_DEV; _BS_DEV
  ICCARM.CCIncludePath2: incl; libr\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: plc1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: libr\stm32f100C8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F10X_MD_VL; UM_DEV; _BS_DEV
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp
  group LIB
    libr/CMSIS/Source/: stm32l1100__it.c system_stm32f10x.c
  group SRC
    ./: Classes.cpp Init.cpp interrupts.cpp rdso.cpp
