# IAR project Backup of MKAB-12.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100C8 ST STM32F100C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD_VL
  ICCARM.CCIncludePath2: $PROJ_DIR$; incl; lib\CMSIS\Include; lib\CMSIS\Source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: MKAB-12.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lib\MKAB-12.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start1
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: AdvClasses.cpp Classes.cpp Init.cpp interrupts.cpp PowerMetr.cpp
    ./: main.cpp
  group Start
    lib/CMSIS/Source/: startup_stm32f10x_md_vl.s stm32l1100__it.c system_stm32f10x.c
