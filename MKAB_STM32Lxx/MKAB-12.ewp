# IAR project MKAB-12.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151C8-A ST STM32L151C8-A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD
  ICCARM.CCIncludePath2: $PROJ_DIR$; incl; lib\CMSIS\Include; lib\CMSIS\Include\Lxx; lib\CMSIS\Source; lib\CMSIS\Source\Lxx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: MKAB-12.txt
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lib\MKAB-12.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: MKAB-12.srec
  ILINK.IlinkIcfFile: Release\MKAB-12.icf
  group (top)
    src/: AdvClasses.cpp Classes.cpp Init.cpp interrupts.cpp PowerMetr.cpp
    ./: main.cpp
  group Start
    lib/CMSIS/Source/Lxx/: startup_stm32l1xx_md.s stm32l1xx_it.c system_stm32l1xx.c
  group StdPerifDriver
    lib/CMSIS/Source/Lxx/: misc.c stm32l1xx_adc.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_usart.c
