# IAR project Bootloader_MKAB-12STM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100C8 ST STM32F100C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD_VL
  ICCARM.CCIncludePath2: libs\inc; lib\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Bootloader_MKAB-12STM.hex
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: Bootloader_MKAB-12STM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L100x6 ST STM32L100x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: incl
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: MKAB-12.srec
  group (top)
    ./: main.cpp
    ../../C/: main.ENU.projtempl
  group LIB
    lib/CMSIS/Source/: stm32l1100__it.c system_stm32f10x.c
  group SRC
    libs/src/: AdvClasses.cpp Classes.cpp Init.cpp interrupts.cpp
