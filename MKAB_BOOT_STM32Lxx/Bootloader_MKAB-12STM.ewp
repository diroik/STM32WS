# IAR project Bootloader_MKAB-12STM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151C8-A ST STM32L151C8-A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD
  ICCARM.CCIncludePath2: libs\inc; lib\CMSIS\Include; lib\CMSIS\Include\Lxx; lib\CMSIS\Source; lib\CMSIS\Source\Lxx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Bootloader_MKAB-12STM.hex
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: lib\Bootloader_MKAB-12STM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L100x6 ST STM32L100x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: incl
  OBJCOPY.OOCOutputFile: MKAB-12.srec
  group (top)
    ./: main.cpp
    ../../C/: main.ENU.projtempl
  group LIB
    lib/CMSIS/Source/Lxx/: stm32l1xx_it.c system_stm32l1xx.c
  group SRC
    libs/src/: AdvClasses.cpp Classes.cpp Init.cpp interrupts.cpp
  group SRC/StdPerifDriver
    lib/CMSIS/Source/Lxx/: stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_usart.c
